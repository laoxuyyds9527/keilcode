# Keil uVision project n32.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB452CEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.5
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: n32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER
  c include: ..\user;..\drivers\inc;..\libraries\CMSIS\core;..\libraries\CMSIS\device;..\libraries\n32wb452_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group startup
    ../libraries/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../libraries/CMSIS/device/: system_n32wb452.c
  group user
    ../user/: main.c n32wb452_it.c
  group drivers
    ../drivers/src/: led.c systick.c fat_core.c gpio.c lte_demo.c tim.c uart.c system.c usart_drv.c
  group libaraies
    ../libraries/n32wb452_std_periph_driver/src/: misc.c n32wb452_adc.c n32wb452_bkp.c n32wb452_can.c n32wb452_crc.c n32wb452_dac.c n32wb452_dbg.c n32wb452_dma.c n32wb452_dvp.c n32wb452_exti.c n32wb452_flash.c n32wb452_gpio.c n32wb452_i2c.c n32wb452_iwdg.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_rtc.c n32wb452_sdio.c n32wb452_spi.c n32wb452_tim.c n32wb452_tsc.c n32wb452_usart.c n32wb452_wwdg.c
